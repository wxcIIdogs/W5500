# Keil uVision project template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\DELAY;..\USART;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\Ethernet;..\HARDWARE\Ethernet\W5500;..\HARDWARE\DHCP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group DELAY
    ../DELAY/: delay.c
  group USART
    ../USART/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Ethernet/: wizchip_conf.c socket.c
    ../HARDWARE/Ethernet/W5500/: w5500.c
    ../HARDWARE/DHCP/: dhcp.c
